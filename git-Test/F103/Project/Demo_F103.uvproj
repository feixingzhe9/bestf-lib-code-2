# Keil uVision project Demo_F103.uvproj, settings and files
target Traget (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BestFu_10127 (library)
  c flags: Optim=1
  c include: ..\Core;..\SysHard\inc;..\..\Lib_code\SysLib\inc;..\..\Lib_code\App;..\User\Signal_Act
  memory RVCT4: ROM 0x8000800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BestFuLib
    ../../Lib_code/SysLib/: BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c Linksimplest.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c Sign433.c Sign433Attr.c SysExeAttr.c SysTestAttr.c Thread.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c
  group Derive
    ../SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
    ../Core/: system_stm32f10x.c startup_stm32f10x_md.s
    ../../Lib_code/App/: main.c UnitCfg.c
  group User
    ../User/Signal_Act/: SigActExeAttr.c SingleUnit.c SingleDrive.c
