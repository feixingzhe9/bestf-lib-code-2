# Keil uVision project Demo_L151.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BestFu_L10127 (library)
  c flags: Optim=1
  c define: STM32L1XX_MD,STM32L151
  c include: ..\..\Lib_code\SysLib\inc;..\SysHard\inc;..\..\Lib_code\App;..\Project;..\Core
  memory RVCT4: ROM 0x8000800 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group BestFuLib
    ../../Lib_code/SysLib/: BestFuLib.c CMDProcess.c Command.c CRC.c Delay.c EEPROM.c FaultManage.c Fifo.c FlashAttr.c LinkScanFifo.c Linksimplest.c Linksrc.c LinkWRDC.c MsgPackage.c Object.c Scene&Group.c SysExeAttr.c SysTestAttr.c Thread.c UnitShare_Attr.c Updata.c Upload.c UserData.c UserDataDownload.c Sign433.c Sign433Attr.c
  group SysHard
    ../SysHard/: DeviceReset.c Flash.c Gpio.c I2C.C Instruct.c Program.c SI4432.c SPI.c Sys.c SysHard.c SysTick.c Test.c Usart.c WDG.c
    ../../Lib_code/App/: main.c
  group User
    ../User/ADC/: ADC.c
    ../User/IIC/: IIC.c
    ../User/MotionSensor/: Cube6.c KeyUnitExeAttr.c led_light.c M74HC595.c MPU6050.c power.c wtc6216.c
